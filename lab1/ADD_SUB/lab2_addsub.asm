
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
MOV R1, #61H
CALL MODADD
CALL MODSUB
HERE: SJMP HERE
ORG 130H
// *****************
MODADD:
MOV A ,#00H
ADD A , 71H
ADD A , 70H
MOV B , R1
DIV AB
MOV 72H , B
RET
MODSUB:
MOV A , #00H
ADD A , 70H
SUBB A , 71H
MOV B , R1

JC LOl 
DIV AB
MOV 73H , B
LOL :

JNC LOL2
MOV B ,A 
MOV A , #9FH
ADD A , #60H
SUBB A , B
ADD A , #01H
MOV B , R1
DIV AB
MOV A , R1
SUBB A , B
MOV 73H , A

LOL2 :


RET

END
