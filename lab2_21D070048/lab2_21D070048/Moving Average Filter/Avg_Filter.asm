LJMP MAIN
ORG 100H
MAIN:
CALL FILT
HERE: SJMP HERE
ORG 130H
// *****************
FILT:

MOV R2 , #61H
MOV R3 , #03H
MOV R1 , #70H
JUMP2 :
MOV A , #00H
MOV R0 , #5FH
JUMP1 :
INC R0
DEC R2
ADD A , @R0
CJNE R2 ,#60H , JUMP1
MOV B , #04H
DIV AB
MOV @R1, A
INC R1
MOV R2 , 00H
INC R2
INC R2
DJNZ R3 , JUMP2  


MOV A , #00H
MOV R0 , #60H
MOV R2 , #63H
MOV R5 , #60H
MOV R3 , #04H
MOV R4 , #05H
SJMP KISHAN
JUMP22 :
INC R5 
MOV R0 , 05H
MOV A , #00H
MOV R3 , #04
KISHAN :
JUMP11 :
ADD A , @R0
INC R0
DJNZ R3 , JUMP11
MOV B , #04H
DIV AB
MOV @R1 , A
INC R1
DJNZ R4 , JUMP22 


RET
END
