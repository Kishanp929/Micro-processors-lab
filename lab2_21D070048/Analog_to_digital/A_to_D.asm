ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE
ORG 130H
// *****************
QUANT:


MOV R0 , #60H
MOV R1 , #70H
MOV R2 , #08H
JUMP :
CLR C
MOV A , @R0
SUBB A , #0AH
JC HERE1

MOV A , @R0
SUBB A , #14H
JC HERE2

MOV A , @R0
SUBB A , #1EH
JC HERE3

JNC HERE4

HERE3 :
MOV @R1 , #19H 
JC LOL1
HERE2 :
MOV @R1 , #0FH 
JC LOL2
HERE1 :
MOV @R1 , #05H
JC LOL3

HERE4 :
MOV @R1 , #23H
LOL1 :
LOL2 :
LOL3 :

INC R0
INC R1

DJNZ R2 , JUMP
RET
END
