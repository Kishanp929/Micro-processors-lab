ORG 00H
LJMP MAIN
ORG 100H
MAIN:
//SETB P1.0
//SETB P1.1
//SETB P1.2
//SETB P1.3

MOV C , P1.3
JC JUMP3

MOV C , P1.2
JC JUMP2

MOV C , P1.1
JC JUMP1

MOV C , P1.0
JC JUMP0


JUMP0:
//SA
MOV TMOD,#01 
HERE: MOV TL0 , #0C9H 
MOV TH0,#0F0H 
CPL P0.7
ACALL DELAY
SJMP HERE

DELAY:
SETB TR0 
AGAIN: JNB TF0,AGAIN 

CLR TR0 
CLR TF0 
RET

//SA end



JUMP1:

//RE
MOV TMOD,#01 
HERE2: MOV TL0 , #9FH 
MOV TH0,#0F2H 
CPL P0.7
ACALL DELAY2
SJMP HERE2

DELAY2:
SETB TR0 
AGAIN2: JNB TF0,AGAIN2 

CLR TR0 
CLR TF0 
RET
//RE end


JUMP2:

//GA
MOV TMOD,#01 
HERE3: MOV TL0 , #12H 
MOV TH0,#0F4H 
CPL P0.7
ACALL DELAY3
SJMP HERE3

DELAY3:
SETB TR0 
AGAIN3: JNB TF0,AGAIN3 
CLR TR0 
CLR TF0 
RET
//GA end

JUMP3:
//MA

MOV TMOD,#01 
HERE4: MOV TL0 , #0C4H 
MOV TH0,#0F4H 
CPL P0.7
ACALL DELAY4
SJMP HERE4

DELAY4:
SETB TR0 
AGAIN4: JNB TF0,AGAIN4 
CLR TR0 
CLR TF0 
RET
//MA end






HERE1: SJMP HERE1
ORG 130H
END